# Keil uVision project 车子.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 车子 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 i2c.c main.c oledchar.c oledchar.h i2c.h stc12c5a.h
